Commit message: update

File: food_apple/model.urdf (robot description, URDF)
Before this commit: robot model.urdf, 1 links, 0 joints
Links:
- link baseLink: geometry collision mesh filename=textured.dae scale=1 1 1; visual mesh filename=textured.dae scale=1 1 1
